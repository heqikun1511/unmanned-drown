<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f01_flight.ewp</path>
  </project>
  <batchBuild />
</workspace>
